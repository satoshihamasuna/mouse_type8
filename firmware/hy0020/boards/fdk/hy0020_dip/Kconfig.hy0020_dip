## firmware/hy0020/boards/fdk/hy0020_dip/board.yml
```yaml
board:
  name: hy0020_dip
  full_name: Akizuki AE-HY0020-DIP
  vendor: fdk
  socs:
    - name: nrf52832
```
